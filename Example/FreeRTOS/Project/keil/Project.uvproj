# Keil uVision project Project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F439ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429X
  c include: ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\..\Libraries\board\inc;..\Demo;..\..\..\..\Libraries\STemWinLibrary520d\inc;..\..\..\..\Libraries\STemWinLibrary520d\Config;..\..\..\..\Libraries\STemWinLibrary520d\OS;..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4xx\FreeRTOS;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\api;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\core;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\core\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\netif;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4xx;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../src/: startup_stm32f429x.s
  group cmsis
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Lwip
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c pbuf.c netif.c raw.c stats.c tcp.c sys.c tcp_in.c tcp_out.c udp.c lwip_timers.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group main
    ../src/: main.c stm32f4x7_eth_bsp.c DC_Config.c DC_Protocol.c DC_Timer.c ambi_prox.c debug_uart.c exti.c flash.c gcom.c i2c.c led_buzzer.c NetEnDeCode.c pir.c rtc.c stm32f4xx_it.c tem_rh.c timer.c wifi.c
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group readme
    ../: readme.txt readme_about_AC.txt
  group ac
    ../src/: AC_Component.c AC_Prime.c AC_RX.c AC_Sub.c AC_TX.c
